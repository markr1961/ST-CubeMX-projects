<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>Project</project>
                <configuration>STM32L073RZ_NUCLEO</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
